FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0001-names-and-thresholds.patch "
