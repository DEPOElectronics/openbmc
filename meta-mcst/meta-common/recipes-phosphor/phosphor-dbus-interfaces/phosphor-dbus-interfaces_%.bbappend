FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0001-enable-Domains-parameter.patch file://0001-enable-HardOff-transition.patch "

SRCREV = "70ee1cff21ade602590f7be9310d68a6903a5bf8"