FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-reimu-6564m-support.patch"
