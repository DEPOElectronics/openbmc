FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-hwclock-make-glibc-2.31-compatible.patch "
