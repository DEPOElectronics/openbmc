FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-serial-config-uart2.patch"
