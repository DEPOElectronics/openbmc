FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://aspeed-bmc-mcst-uid-gpio-acthi.dtsi"
