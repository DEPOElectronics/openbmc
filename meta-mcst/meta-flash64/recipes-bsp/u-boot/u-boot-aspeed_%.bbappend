FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += " file://0002-set-env-and-boot-addresses.patch "
