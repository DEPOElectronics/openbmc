FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-serial-config-uart2.patch file://0002-set-required-gpios.patch"
