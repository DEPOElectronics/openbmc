FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://aspeed-bmc-mcst-reimu-6564m.dts"
