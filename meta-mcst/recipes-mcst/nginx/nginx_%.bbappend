do_install_append() {
    rm -f ${D}/etc/nginx/sites-enabled/default_server
}
