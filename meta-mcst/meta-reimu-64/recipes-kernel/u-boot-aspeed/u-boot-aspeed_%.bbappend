FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0002-set-required-gpios.patch"
