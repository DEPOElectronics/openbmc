FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://aspeed-bmc-mcst-tinyspi.dtsi file://aspeed-bmc-mcst-mus-2600.dtsi"
