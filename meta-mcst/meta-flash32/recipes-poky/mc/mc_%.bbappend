do_install_append() {
    rm ${D}/usr/share/mc/help/mc.hlp.{es,hu,it,pl,sr}
}
