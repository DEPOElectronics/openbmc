OBMC_IMAGE_EXTRA_INSTALL:append = " \
  webui-vue \
  "
