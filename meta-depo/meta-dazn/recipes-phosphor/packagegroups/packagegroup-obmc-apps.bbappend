RDEPENDS:${PN}-inventory:append:dazn = " id-button"
